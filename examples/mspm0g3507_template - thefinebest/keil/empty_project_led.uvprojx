# Keil uVision project empty_project_led.uvprojx, settings and files
target empty_project_led (6150000::V6.15::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  BeforeMake: cmd.exe /C "$P../../../tools/keil/syscfg.bat '$P' ncontroller.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\source;..\..\mspm0g3507_template - thefinebest;..\ndrivers;..\ndrivers\oled;..\ndrivers\IMU\mpu6050;..\ndrivers\IMU\mpu6050\eMPL;..\task;..\ndrivers\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../../../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../../../source/ti/driverlib/m0p/: dl_interrupt.c
    ../../../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0g1x0x_g3x0x.h
  group User
    ../: main.c main.h ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group ndrivers
    ../ndrivers/: drv_uart.c drv_timer.c drv_car.c pid.c drv_led.c drv_key.c drv_flash.c drv_adc.c drv_sensor.c system.c drv_gpio.c
    ../ndrivers/oled/: drv_oled.c
    ../ndrivers/IMU/mpu6050/: drv_mpu6050.c
    ../ndrivers/IMU/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group task
    ../task/: gui.c Task1.c Task2.c Task3.c Task3.h Task5.c Task5.h
  group IMU
    ../ndrivers/IMU/: IMU.c Smooth_Filter.c kalman.c
